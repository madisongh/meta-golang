require golang-native.inc
require golang-${PV}.inc
