require golang-cross.inc
require golang-${PV}.inc
