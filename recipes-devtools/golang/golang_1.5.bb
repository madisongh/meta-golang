require recipes-devtools/golang/golang-${PV}.inc
require golang-target.inc
