require recipes-devtools/golang/golang-${PV}.inc
require golang-runtime.inc
