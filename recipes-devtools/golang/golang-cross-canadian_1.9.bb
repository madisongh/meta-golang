require golang-cross-canadian.inc
require golang-${PV}.inc
